Commit message: added urdf and respective yaml file

File: 03_ROS/ghost_localization/maps/pushBackField.urdf (robot description, URDF)
Before this commit: robot push_back_field, 1 links, 0 joints
Links:
- link map: geometry collision box size=0.56 0.125 0.125; collision box size=0.56 0.125 0.125
